# Keil uVision project SolutionDev.uvprojx, settings and files
target STM32F429IIHx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SolutionDev
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: .\Code\Driver\Helper;.\Code\Driver\Official\W5500;.\Code\Driver\Official\STM32F4xx_StdPeriph_Driver_V1.8.0\inc;.\Code\Driver\System;.\Code\Controller
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group System
    ./Code/Driver/System/: startup_stm32f429_439xx.s system_stm32f4xx.c
  group Helper
    ./Code/Driver/Helper/: DelayAdapter.c LedAdapter.c TimAdapter.c UartAdapter.c CanAdapter.c ExtiAdapter.c FmcAdapter.c UdpAdapter.c SPIAdapter.c AUartAdapter.c DRamAdapter.c
  group StdDriver
    ./Code/Driver/Official/STM32F4xx_StdPeriph_Driver_V1.8.0/src/: stm32f4xx_can.c misc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_spi.c stm32f4xx_rtc.c
  group W5500
    ./Code/Driver/Official/W5500/: w5500.c wizchip_conf.c
  group Controller
    ./Code/Controller/: main.c
